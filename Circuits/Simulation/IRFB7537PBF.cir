.SUBCKT irfb7537pbf 1 2 3
* SPICE3 MODEL WITH THERMAL RC NETWORK
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Feb 21, 14
* MODEL FORMAT: SPICE3
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=4.07761 LAMBDA=0.0693124 KP=360.824
+CGSO=6.1222e-05 CGDO=1.96023e-06
RS 8 3 0.00130897
D1 3 1 MD
.MODEL MD D IS=9.95321e-10 RS=0.00112535 N=1.21937 BV=60
+IBV=0.00025 EG=1.2 XTI=4 TT=1e-07
+CJO=1.48589e-09 VJ=0.697854 M=0.479937 FC=0.5
RDS 3 1 2e+08
RD 9 1 0.00120781
RG 2 7 3.10123
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=3.01883e-09 VJ=0.5 M=0.69461 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 6.15822e-09
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS irfb7537pbf

*SPICE Thermal Model Subcircuit
.SUBCKT irfb7537pbft 3 0

R_RTHERM1         3 2  0.0641
R_RTHERM2         2 1  0.2512
R_RTHERM3         1 0  0.3334
C_CTHERM1         3 2  0.00177
C_CTHERM2         2 1  0.00972
C_CTHERM3         1 0  0.04799

.ENDS irfb7537pbft
